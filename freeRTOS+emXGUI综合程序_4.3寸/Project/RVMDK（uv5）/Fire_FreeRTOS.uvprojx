# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target Fire_FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Fire_FreeRTOS +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER,STM32F767xx,X_GUI_USE_FREERTOS,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F7,NDEBUG,
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F7xx\Include;..\..\Libraries\STM32F7xx_HAL_Driver\Inc;..\..\User;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM7\r0p1;..\..\User\delay;..\..\User\key;..\..\User\led;..\..\User\usart;..\..\User\bsp;..\..\emXGUI_Lib;..\..\emXGUI_Lib\app\base;..\..\emXGUI_Lib\drv;..\..\emXGUI_Lib\arch\Inc;..\..\emXGUI_Lib\inc;..\..\User\FATFS;..\..\User\bsp\cm_backtrace;..\..\User\bsp\app\GUI_Demo;..\..\User\bsp\app\Board_App;..\..\User\OwnerDraw;..\..\User\bsp\app\Board_App\gyro;..\..\User\bsp\app\Board_App\gyro\mpu6050\driver\include;..\..\User\bsp\app\Board_App\gyro\mpu6050\driver\eMPL;..\..\User\bsp\app\Board_App\gyro\mpu6050\mllite;..\..\User\bsp\app\Board_App\gyro\mpu6050\mpl;..\..\User\bsp\app\Board_App\gyro\mpu6050\eMPL-hal;..\..\User\bsp\app\Board_App\gyro\mpu6050\driver\stm32L;..\..\User\bsp\app\Board_App\mp3_decoder\pub;..\..\..\..\demo_code_f767;..\..\User\bsp\app\Board_App\camera\QR_Decoder;..\..\User\bsp\app\Board_App\Phone_SMS\bsp_sim;..\..\User\bsp\app\Board_App\NetworkDLG;..\..\User\bsp\app\Board_App\NetworkDLG\lwipapp;..\..\User\bsp\app\Board_App\NetworkDLG\arch;..\..\User\bsp\app\Board_App\NetworkDLG\lwipapp;..\..\User\bsp\app\Board_App\NetworkDLG\LwIP\include\lwip;..\..\User\bsp\app\Board_App\NetworkDLG\LwIP\include\netif;..\..\User\bsp\app\Board_App\NetworkDLG\LwIP\include;..\..\User\bsp\app\Board_App\NetworkDLG\bsp\LAN8720A
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\..\Output\Fire_FreeRTOS.sct
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f767xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group STM32F7xx_HAL_Driver
    ../../Libraries/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group USER
    ../../User/: main.c stm32f7xx_it.c FreeRTOSConfig.h cpuusage.c board.h
  group BSP
    ../../User/bsp/lcd/: bsp_lcd.c
    ../../User/bsp/led/: bsp_led.c
    ../../User/bsp/sdram/: bsp_sdram.c
    ../../User/bsp/usart/: bsp_debug_usart.c
    ../../User/bsp/key/: bsp_key.c
    ../../User/bsp/touch/: bsp_i2c_touch.c gt9xx.c
    ../../User/bsp/flash/: bsp_qspi_flash.c
    ../../User/bsp/sdmmc/: bsp_sdmmc_sd.c
    ../../User/bsp/tim/: bsp_basic_tim.c
    ../../User/bsp/mpu/: bsp_mpu.c
    ../../User/bsp/beep/: bsp_beep.c
    ../../User/bsp/delay/: core_delay.c
    ../../User/bsp/wm8978/: bsp_wm8978.c
    ../../User/bsp/i2c/: i2c.c bsp_i2c.c
    ../../User/bsp/dma2d/: dma2d_emxgui.c
  group Fatfs
    ../../User/FATFS/: diskio.c ff.c ffconf.h sd_diskio.c ff_gen_drv.c
    ../../User/FATFS/option/: cc936.c extern_cc936.c
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM7/r0p1/: port.c
  group OEM_Face
    ../../emXGUI_Lib/OEM_Face/: OEM_Button.c OEM_CheckBox.c OEM_GroupBox.c OEM_ListBox.c OEM_ProgressBar.c OEM_RadioBox.c OEM_ScrollBar.c OEM_TextBox.c
  group emxgui/arch
    ../../emXGUI_Lib/arch/: GUI_Arch.c GUI_GPU.c
    ../../emXGUI_Lib/arch/Inc/: gui_os_port.h gui_drv.h
    ../../emXGUI_Lib/arch/OS_Options/: X_GUI_FreeRTOS.c
  group emxgui/resource
    ../../emXGUI_Lib/resource/xft_font/: ASCII_16_4BPP.c ASCII_20_4BPP.c ASCII_24_4BPP.c GB2312_16_2BPP.c
  group emxgui/drv
    ../../User/: gui_drv_cfg.h
    ../../emXGUI_Lib/drv/: gui_font_port.c gui_fs_port.c gui_input_port.c gui_lcd_port.c gui_log_port.c gui_mem_port.c gui_picture_port.c gui_resource_port.c gui_touch_port.c
  group emxgui/inc
    ../../emXGUI_Lib/inc/: Clist.h def.h emXGUI.h emXGUI_Arch.h emXGUI_JPEG.h emxgui_png.h GUI_Font_XFT.h Web_Color.h x_libc.h x_obj.h 说明.txt
    ../../emXGUI_Lib/app/base/: GUI_AppDef.h
  group emxgui/libs
    ../../emXGUI_Lib/libs/: emXGUI100_MDK_M7.lib libpng_MDK_M7.lib x_libc_MDK_M7.lib x_obj.cpp 说明.txt libjpeg_MDK_M7.lib
  group base_app
    ../../emXGUI_Lib/drv/: gui_startup.c
    ../../emXGUI_Lib/app/base/: gui_desktop.c
    ../../emXGUI_Lib/app/base/boot_interface/: GUI_Boot_Interface_Dialog.c
    ../../emXGUI_Lib/app/base/pic_load/: gui_pic_load.c
    ../../emXGUI_Lib/app/base/res_writer/: backend_res_writer.c GUI_RES_Writer_Dialog.c
    ../../User/bsp/app/Board_App/: GUI_Board_App_Desktop.c
    ../../User/bsp/app/GUI_Demo/: GUI_DEMO_SlideWindow.c
  group app_res
    ../../emXGUI_Lib/app/base/boot_interface/: boot_logo.c
  group cm_backtrace
    ../../User/bsp/cm_backtrace/: cm_backtrace.c
    ../../User/bsp/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group DOC
    ../../: 必读说明.txt
  group GUI_APP
    ../../User/bsp/app/GUI_Demo/: CListMenu.cpp GUI_App_Desktop.c GUI_DEMO_AutoMeter.c GUI_DEMO_Button.c GUI_DEMO_Button_OwnerDraw.c GUI_DEMO_Checkbox.c GUI_DEMO_Graphics_Accelerator.c GUI_DEMO_Listbox.c GUI_DEMO_Messagebox.c GUI_DEMO_Number_Keyboard.c GUI_DEMO_Progressbar.c GUI_DEMO_RadiaMenu.c GUI_DEMO_Radiobox.c GUI_DEMO_Scrollbar.c GUI_DEMO_Textbox.c GUI_SelectDialogBox.c calculator.cpp GUI_DEMO_ShowWave.cpp
  group tutorial/setting
    ../../User/bsp/app/Board_App/setting/: GUI_DEMO_Settings.c
  group tutorial/clock
    ../../User/bsp/app/Board_App/clock/: GUI_CLOCK_DIALOG.c
    ../../User/bsp/app/Board_App/clock/RTC/: bsp_rtc.c
  group tutorial/pic_viwer
    ../../User/bsp/app/Board_App/pic_viewer/: GUI_PicViewr_Dialog.c
    ../../User/OwnerDraw/: Widget.c
  group tutorial/LED&KEY
    ../../User/bsp/app/Board_App/LED_Key/: GUI_LED_KEY_Dialog.c
  group tutorial/beep
    ../../User/bsp/app/Board_App/beeper_control/: GUI_Beeper_Dialog.c
  group tutorial/rgb_led
    ../../User/bsp/app/Board_App/rgb_led/: Backend_RGBLED.c GUI_RGBLED_DIALOG.c
  group tutorial/adc
    ../../User/bsp/app/Board_App/adc_Collect_voltage/: GUI_ADC_CollectVoltage_Dialog.c
    ../../User/bsp/adc/: bsp_adc.c
  group tutorial/dth11
    ../../User/bsp/app/Board_App/T_RH/: GUI_T_RH_Dialog.c
    ../../User/bsp/app/Board_App/T_RH/dht11/: bsp_dht11.c
  group tutorial/gyro
    ../../User/bsp/app/Board_App/gyro/: GUI_Gyro_Dialog.c
    ../../User/bsp/app/Board_App/gyro/mpu6050/: bsp_mpu_exti.c
    ../../User/bsp/app/Board_App/gyro/i2c_for_mpu6050/: MPU6050_i2c.c
  group tutorial/video_player
    ../../User/bsp/app/Board_App/video_player/: Backend_avifile.c Backend_vidoplayer.c GUI_VEDIOPLAYER_DIALOG.c
  group tutorial/mp3
    ../../User/bsp/app/Board_App/mp3_player/: GUI_MusicList_DIALOG.c Backend_mp3Player.c GUI_MUSICPLAYER_DIALOG.c
  group tutorial/bsp_mp3
    ../../User/bsp/app/Board_App/mp3_decoder/: mp3dec.c mp3tabs.c
    ../../User/bsp/app/Board_App/mp3_decoder/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c assembly.h coder.h
    ../../User/bsp/app/Board_App/mp3_decoder/real/arm/: asmmisc.s asmpoly_thumb2.s
    ../../User/bsp/app/Board_App/mp3_decoder/pub/: mp3common.h mp3dec.h mpadecobjfixpt.h statname.h
  group tutorial/recorder
    ../../User/bsp/app/Board_App/recorder/: Backend_Recorder.c GUI_RECORDER_DIALOG.c
  group tutorial/camera
    ../../User/bsp/app/Board_App/camera/: bsp_ov5640.c GUI_Camera_Dialog.c GUI_Camera_QRCode_Dialog.c ov5640_AF.c
    ../../User/bsp/app/Board_App/camera/QR_Decoder/: QR_Core.lib
  group tutorial/PhoneCallMonitorTask
    ../../User/bsp/app/Board_App/Phone_SMS/: GUI_Phone_Dialog.c GUI_SMS_Dialog.c
    ../../User/bsp/app/Board_App/Phone_SMS/bsp_sim/: bsp_gsm_gprs.c bsp_gsm_usart.c
  group tutorial/lwip
    ../../User/bsp/app/Board_App/NetworkDLG/: GUI_Network_Dialog.c
    ../../User/bsp/app/Board_App/NetworkDLG/bsp/LAN8720A/: LAN8720A.c
  group MPU_eMPL
    ../../User/bsp/app/Board_App/gyro/mpu6050/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../User/bsp/app/Board_App/gyro/mpu6050/driver/stm32L/: log_stm32.c
    ../../User/bsp/app/Board_App/gyro/mpu6050/eMPL-hal/: eMPL_outputs.c
  group MPU_mllite
    ../../User/bsp/app/Board_App/gyro/mpu6050/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
  group MPU_mpl
    ../../User/bsp/app/Board_App/gyro/mpu6050/mpl/libmpllib_Keil_M4FP/: libmpllib.lib
  group LwIP/core
    ../../User/bsp/app/Board_App/NetworkDLG/LwIP/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../User/bsp/app/Board_App/NetworkDLG/LwIP/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LwIP/arch
    ../../User/bsp/app/Board_App/NetworkDLG/arch/: sys_arch.c ethernetif.c sys_arch.h lwipopts.h
  group LwIP/app
    ../../User/bsp/app/Board_App/NetworkDLG/lwipapp/: tcp_echoclient.c tcp_echoserver.c udp_echoclient.c udp_echoserver.c tcpecho.c
  group LwIP/api
    ../../User/bsp/app/Board_App/NetworkDLG/LwIP/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/netif
    ../../User/bsp/app/Board_App/NetworkDLG/LwIP/netif/: bridgeif.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
software components: Compiler:I/O:STDERR 1.2.0
